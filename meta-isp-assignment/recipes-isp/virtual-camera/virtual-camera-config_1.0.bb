SUMMARY = "Camera definition and test frames for libcamera's virtual pipeline handler"
DESCRIPTION = "Declares one 1080p30 virtual camera and ships the synthetic \
test-chart frames it plays. The frames are generated by \
scripts/gen-test-frames.py in the project repository."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SRC_URI = "file://virtual.yaml \
           file://frames"

inherit allarch

do_configure[noexec] = "1"
do_compile[noexec] = "1"

do_install() {
    # libcamera looks for <datadir>/libcamera/pipeline/virtual/virtual.yaml.
    install -D -m 0644 ${WORKDIR}/virtual.yaml \
        ${D}${datadir}/libcamera/pipeline/virtual/virtual.yaml
    install -d ${D}${datadir}/isp-channel/frames
    install -m 0644 ${WORKDIR}/frames/*.jpg ${D}${datadir}/isp-channel/frames/
}

FILES:${PN} = "${datadir}/libcamera/pipeline/virtual ${datadir}/isp-channel"
